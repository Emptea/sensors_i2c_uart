# Keil uVision project sensors_i2c_uart.uvprojx, settings and files
target sensors_i2c_uart (6190000::V6.19::ARMCLANG)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: sensors_i2c_uart +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F031x6,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT5: ROM 0x8007c00 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f031x6.s
  group Application/User/Core
    ../Core/Src/: lm75bd.c tmp112.c sht3x_dis.c bmp180.c uid_hash.c crc16.c main.c gpio.c i2c.c usart.c stm32f0xx_it.c tim.c sensors.c usart_ex.c iwdg.c flash.c calibration.c debug.c i2c_ex.c
    ./: zs05.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_dma.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_ll_pwr.c stm32f0xx_ll_usart.c stm32f0xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 5.6.0
